# Keil uVision project irtousb.uvprojx, settings and files
target STM32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F070CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: irtousb +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0xx_StdPeriph_Driver\src;.\Main;.\USB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Main Code
    ./Main/: main.c stm32f0xx_conf.h led.h led.c usb.h usb.c
  group USB
    ./USB/: usbd_hid_core.h usbd_req.h usbd_ioreq.h usbd_def.h usbd_conf.h usbd_core.h usb_dcd.h usb_core.h usb_regs.h usb_dcd_int.h usbd_pwr.h usb_bsp.h usbd_desc.h usb_conf.h usbd_usr.h usbd_hid_core.c usbd_core.c usbd_usr.c usbd_desc.c usb_dcd.c usbd_req.c usbd_ioreq.c usb_bsp.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0
